# Keil uVision project Sorttrolley.uvprojx, settings and files
target Sorttrolley (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Sorttrolley +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Package/system_tick/inc;../Package/common_protocol/inc;../Package/uart_dma_driver/inc;../App/app_rs485/inc;../Package/data_manager/inc;../Package/data_manager/port;../LWIP/App;../LWIP/Target;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/compat/posix;../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../Middlewares/Third_Party/LwIP/src/include/compat/stdc;../Middlewares/Third_Party/LwIP/system/arch;../Package/eth_udp_driver/inc;../Drivers/BSP/Components/dp83848;../ModbusPort;../ModbusTCP/tcp;../ModbusTCP/include;../App/app_modbustcp_tx_rx;../Package/limit_driver/inc;../Package/motor_driver/inc;../Package/raster_driver/inc;../Package/rs485_driver/inc;../Package/led_driver/inc;../App/app_car_control/inc;../Package/lidar_driver/inc;../Package/eth_tcp_driver/inc;../App/app_eth_tcp_udp/inc;../App/app_diagnosis/inc;../Sfud/inc;../Sfud/port;../EasyFlash/inc;../Package/adc_driver/inc;../Package/iwdg_driver/inc;../Package/pid_driver/inc;../App/app_mqtt_tx/inc;../Package/mqtt_driver/inc;../Package/mqtt_protocol/inc;../Package/crypto/crypto_get_pass/inc;../Package/crypto/crypto_sha256/inc;../App/app_mqtt_rx/inc;../Package/flash_parameter/inc
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dac.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_eth.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group App
    ../App/app_car_control/src/: app_car_control.c
    ../App/app_rs485/src/: app_rs485.c
    ../App/app_eth_tcp_udp/src/: app_eth_tcp_udp.c
    ../App/app_diagnosis/src/: app_diagnosis.c
    ../App/app_mqtt_tx/src/: app_mqtt_tx.c
    ../App/app_mqtt_rx/src/: app_mqtt_rx.c
  group Package
    ../Package/system_tick/src/: system_tick.c
    ../Package/common_protocol/src/: common_protocol.c crc.c ringBuffer.c
    ../Package/uart_dma_driver/src/: usart_dma_driver.c
    ../Package/data_manager/src/: data_manager.c
    ../Package/eth_udp_driver/src/: eth_udp_driver.c
    ../Package/eth_tcp_driver/src/: eth_tcp_driver.c
    ../Package/limit_driver/src/: limit_driver.c
    ../Package/motor_driver/src/: motor_driver.c
    ../Package/raster_driver/src/: raster_driver.c
    ../Package/rs485_driver/src/: rs485_driver.c
    ../Package/led_driver/src/: led_driver.c
    ../Package/lidar_driver/src/: lidar_driver.c
    ../Package/iwdg_driver/src/: iwdg_driver.c
    ../Package/adc_driver/src/: adc_driver.c
    ../Package/pid_driver/src/: pid_driver.c
    ../Package/mqtt_driver/src/: mqtt_driver.c
    ../Package/mqtt_protocol/src/: mqtt_protocol.c convert_endian.c
    ../Package/crypto/crypto_sha256/src/: sha256.c
    ../Package/crypto/crypto_get_pass/src/: crypto_get_pass.c
    ../Package/flash_parameter/src/: flash_parameter.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/dp83848/: dp83848.c
  group Sfud
    ../Sfud/src/: sfud.c sfud_sfdp.c
    ../Sfud/port/: spi_sfud_port.c
  group EasyFlash
    ../EasyFlash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ../EasyFlash/port/: ef_port.c
software components: CMSIS:CORE 4.3.0
